<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Template</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>board</name>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_adc_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_adc_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_capture.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_capture.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_encoder_emulation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_encoder_emulation.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_filter_lp3kHz.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_filter_lp3kHz.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_gpio_table.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_lcd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_motor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_NVIC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_NVIC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_spi_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_spi_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_state.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_state.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_sys_tick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_sys_tick.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_system_type.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board_uart.h</name>
    </file>
  </group>
  <group>
    <name>CMSYS</name>
    <file>
      <name>$PROJ_DIR$\..\Libs\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f429_439xx.s</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <file>
      <name>$PROJ_DIR$\..\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\main.h</name>
    </file>
  </group>
  <group>
    <name>STM32F429I-Discovery</name>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_i2c_ee.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_i2c_ee.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_ioe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_ioe.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_l3gd20.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_l3gd20.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_lcd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_sdram.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F429I-Discovery\stm32f429i_discovery_sdram.h</name>
    </file>
  </group>
  <group>
    <name>STM32F4xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_fmc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_ltdc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libs\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>system</name>
    <file>
      <name>$PROJ_DIR$\..\system\stm32f4xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\system\stm32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\system\stm32f4xx_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\system\system_stm32f4xx.c</name>
    </file>
  </group>
</project>


