# IAR project prn_analog_stm32f4.ewp, settings and files
configuration Template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\Libs\CMSIS\Device\ST\STM32F4xx\Include; ..\Libs\CMSIS\Include; ..\Libs\STM32F4xx_StdPeriph_Driver\inc; ..\Libs\STM32F429I-Discovery; ..\Libs\Common; ..\system; ..\src; ..\src\board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: print_stm32f4.srec
  ILINK.IlinkOutputFile: print_stm32f4.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../src/board/: board_adc_dma.c board_adc_dma.h board_capture.c board_capture.h board_encoder_emulation.c board_encoder_emulation.h board_filter_lp3kHz.c board_filter_lp3kHz.h board_gpio.c board_gpio.h board_gpio_table.h board_init.c board_init.h board_lcd.c board_lcd.h board_motor.c board_motor.h board_NVIC.c board_NVIC.h board_spi_dma.c board_spi_dma.h board_state.c board_state.h board_sys_tick.c board_sys_tick.h board_system_type.h board_uart.c board_uart.h
  group CMSYS
    ../Libs/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group src
    ../src/: main.c main.h
  group STM32F429I-Discovery
    ../Libs/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_i2c_ee.h stm32f429i_discovery_ioe.c stm32f429i_discovery_ioe.h stm32f429i_discovery_l3gd20.c stm32f429i_discovery_l3gd20.h stm32f429i_discovery_lcd.c stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.c stm32f429i_discovery_sdram.h
  group STM32F4xx_StdPeriph_Driver
    ../Libs/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Libs/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_fmc.h stm32f4xx_ltdc.h
  group system
    ../system/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
